# Keil uVision project Proj.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Proj +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
  group src
    ./src/: Beep.c demo.c Globle.c KeyScan.c Lcd.c LED.c SN74LS595.c Timer.c Date.c
