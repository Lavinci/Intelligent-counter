# Keil uVision project demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: demo +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 demo.c
  group func
    ./: STC15.H Lcd.h KeyScan.h Globle.h KeyScan.c Lcd.c Globle.c LED.c LED.h SN74LS595.c SN74LS595.h Beep.c Beep.h
